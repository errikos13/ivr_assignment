Commit message: Add files via upload

File: urdf/object.urdf (robot description, URDF)
Before this commit: robot myrobot, 6 links, 5 joints
Joints:
- joint target: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 -0.3 rpy=0 0 0
